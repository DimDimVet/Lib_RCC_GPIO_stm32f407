# Keil uVision project LibRCC.uvprojx, settings and files
target LibRCC (6190000::V6.19::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LibRCC
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=4
  c include: ..\LibRCC;.\inc;.\inc_lib
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ./app/: app.c stm32f105_usbdfs_cdc.c stm32f407_clock.c
  group lib
    ./lib/: lib_stm32.c GPIO_STM32F407.c RCC_STM32F407.c
  group inc
    ./inc/: app.h stm32f105_usbdfs_cdc.h stm32f105_usbdfs_macros.h usb_cdc_desc.h stm32f407_clock.h
  group inc_lib
    ./inc_lib/: lib_stm32.h GPIO_STM32F407.h RCC_STM32F407.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
